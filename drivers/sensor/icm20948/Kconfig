## drivers/sensor/icm20948/Kconfig
```kconfig
menuconfig ICM20948
    bool "ICM20948 sensor"
    depends on I2C
    help
      Enable driver for the ICM20948 9-axis IMU sensor.
```
